<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MiCOKit-G55</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\helloworld\hello_world.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>MiCOKit-G55</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-G55\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-G55\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-G55\platform_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MICODriverNanoSecond.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\Debug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>libraries</name>
    <group>
      <name>daemon</name>
      <group>
        <name>homekit_server</name>
      </group>
      <group>
        <name>http_server</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http-strings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http_parse.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_handle.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_ssi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_sys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_wsgi.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>utilities</name>
      <group>
        <name>json_c</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\arraylist.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_tokener.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_util.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\linkhash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\printbuf.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\AESUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\CheckSumUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\HTTPUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\RingBufferUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SecurityUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SHAUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SocketUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\StringUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TimeUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TLVUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\URLUtils.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>mico</name>
    <group>
      <name>core</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\core\mico_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\core\mxchipWNet_cm4f_spi.a</name>
      </file>
    </group>
    <group>
      <name>security</name>
      <group>
        <name>curve25519</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\security\Curve25519\curve25519-donna.c</name>
        </file>
      </group>
      <group>
        <name>SHA</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\security\SHAUtils\hkdf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\security\SHAUtils\hmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\security\SHAUtils\sha-private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\security\SHAUtils\sha.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\security\SHAUtils\sha1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\security\SHAUtils\sha224-256.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\security\SHAUtils\sha384-512.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\security\SHAUtils\usha.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\security\MicoCrypto.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\security\MicoSrpServer.a</name>
      </file>
    </group>
    <group>
      <name>system</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\airkiss_discovery\airkiss_discovery.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\config_server\config_server.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\config_server\config_server_menu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\airkiss_discovery\lib_airkiss\libairkiss.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\libMFiWAC.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\command_console\mico_cli.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mdns\mico_mdns.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_monitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_notification.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_para_storage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_power_daemon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mdns\system_discovery.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\system_easylink.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\system_easylink_delegate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\system_easylink_wac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\system_factory_test.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\system_misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\tftp_ota\tftp_ota.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\tftp_ota\tftpc.o</name>
      </file>
    </group>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M4</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M4\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M4\hardfault.c</name>
      </file>
    </group>
    <group>
      <name>Drivers</name>
      <group>
        <name>display</name>
        <group>
          <name>VGM128064</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\display\VGM128064\AsciiLib.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\display\VGM128064\AsciiLib.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\display\VGM128064\oled.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\display\VGM128064\oled.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\display\VGM128064\oledfont.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>keypad</name>
        <group>
          <name>gpio_button</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\keypad\gpio_button\button.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\keypad\gpio_button\button.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>led</name>
        <group>
          <name>P9813</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\rgb_led\P9813\hsb2rgb_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\rgb_led\P9813\hsb2rgb_led.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\rgb_led\P9813\rgb_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\rgb_led\P9813\rgb_led.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>MFiAuth</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MicoDriverMFiAuth\MicoDriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>MiCOKit-EXT</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\micokit_ext.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\micokit_ext.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\micokit_ext_def.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\micokit_ext_mfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\motion_sensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\motion_sensor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_EXT\temp_hum_sensor.c</name>
        </file>
      </group>
      <group>
        <name>MiCOKit-STmem</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_STmems\MiCOKit_STmems.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_STmems\MiCOKit_STmems.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MiCOKit_STmems\MiCOKit_STmems_def.h</name>
        </file>
      </group>
      <group>
        <name>motor</name>
        <group>
          <name>dc_motor</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\motor\dc_motor\dc_motor.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\motor\dc_motor\dc_motor.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>sensor</name>
        <group>
          <name>ADPS9930</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\apds9930\apds9930.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\apds9930\apds9930.h</name>
          </file>
        </group>
        <group>
          <name>BMA2x2</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMA2x2\bma2x2.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMA2x2\bma2x2.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMA2x2\bma2x2_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMA2x2\bma2x2_user.h</name>
          </file>
        </group>
        <group>
          <name>BME280</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BME280\bme280.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BME280\bme280.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BME280\bme280_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BME280\bme280_user.h</name>
          </file>
        </group>
        <group>
          <name>BMG160</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMG160\bmg160.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMG160\bmg160.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMG160\bmg160_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMG160\bmg160_user.h</name>
          </file>
        </group>
        <group>
          <name>BMM050</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMM050\bmm050.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMM050\bmm050.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMM050\bmm050_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\BMM050\bmm050_user.h</name>
          </file>
        </group>
        <group>
          <name>DHT11</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\DHT11\DHT11.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\DHT11\DHT11.h</name>
          </file>
        </group>
        <group>
          <name>HTS221</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\HTS221\hts221.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\HTS221\hts221.h</name>
          </file>
        </group>
        <group>
          <name>infrared_adc</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\infrared_adc\infrared_reflective.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\infrared_adc\infrared_reflective.h</name>
          </file>
        </group>
        <group>
          <name>light_adc</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\light_adc\light_sensor.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\light_adc\light_sensor.h</name>
          </file>
        </group>
        <group>
          <name>LPS25HB</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\LPS25HB\lps25hb.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\LPS25HB\lps25hb.h</name>
          </file>
        </group>
        <group>
          <name>LSM9DS1</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\LSM9DS1\lsm9ds1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\LSM9DS1\lsm9ds1_acc_gyr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\LSM9DS1\lsm9ds1_mag.c</name>
          </file>
        </group>
        <group>
          <name>UVIS25</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\UVIS25\uvis25.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\sensor\UVIS25\uvis25.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>SPI Flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash_platform.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\close.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\lseek.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\remove.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>MCU</name>
      <group>
        <name>ATSAMG55</name>
        <group>
          <name>EWARM</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\EWARM\startup_ATSAMG55_EWARM.s</name>
          </file>
        </group>
        <group>
          <name>Peripherals</name>
          <group>
            <name>Libraries</name>
            <group>
              <name>asf-3.22.0</name>
              <group>
                <name>common</name>
                <group>
                  <name>services</name>
                  <group>
                    <name>clock</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\clock\samg\sysclk.c</name>
                    </file>
                  </group>
                  <group>
                    <name>sleepmgr</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\services\sleepmgr\sam\sleepmgr.c</name>
                    </file>
                  </group>
                </group>
                <group>
                  <name>utils</name>
                  <group>
                    <name>interrupt</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\common\utils\interrupt\interrupt_sam_nvic.c</name>
                    </file>
                  </group>
                </group>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\utils\interrupt\interrupt_sam_nvic.c</name>
                </file>
              </group>
              <group>
                <name>sam</name>
                <group>
                  <name>drivers</name>
                  <group>
                    <name>adc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\adc\adc2.c</name>
                    </file>
                  </group>
                  <group>
                    <name>efc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\efc\efc.c</name>
                    </file>
                  </group>
                  <group>
                    <name>flexcom</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\flexcom\flexcom.c</name>
                    </file>
                  </group>
                  <group>
                    <name>matrix</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\matrix\matrix.c</name>
                    </file>
                  </group>
                  <group>
                    <name>pdc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pdc\pdc.c</name>
                    </file>
                  </group>
                  <group>
                    <name>pio</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pio\pio.c</name>
                    </file>
                  </group>
                  <group>
                    <name>pmc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pmc\pmc.c</name>
                    </file>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\pmc\sleep.c</name>
                    </file>
                  </group>
                  <group>
                    <name>rtt</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\rtt\rtt.c</name>
                    </file>
                  </group>
                  <group>
                    <name>spi</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\spi\spi.c</name>
                    </file>
                  </group>
                  <group>
                    <name>supc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\supc\supc.c</name>
                    </file>
                  </group>
                  <group>
                    <name>twi</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\twi\twi.c</name>
                    </file>
                  </group>
                  <group>
                    <name>usart</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\usart\usart.c</name>
                    </file>
                  </group>
                  <group>
                    <name>wdt</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\drivers\wdt\wdt.c</name>
                    </file>
                  </group>
                </group>
                <group>
                  <name>services</name>
                  <group>
                    <name>flash_efc</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\services\flash_efc\flash_efc.c</name>
                    </file>
                  </group>
                </group>
                <group>
                  <name>utils</name>
                  <group>
                    <name>cmsis</name>
                    <file>
                      <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\asf-3.22.0\sam\utils\cmsis\samg\samg55\source\templates\system_samg55.c</name>
                    </file>
                  </group>
                </group>
              </group>
            </group>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\paltform_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_mcu_powersave.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_nano_second.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_pwm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_watchdog.c</name>
          </file>
        </group>
        <group>
          <name>wlan_bus_driver</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\wlan_bus_driver\wlan_bus_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\wlan_bus_driver\wlan_platform.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\platform_init.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\mico_platform_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\wlan_platform_common.c</name>
      </file>
    </group>
  </group>
</project>


